# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: cmd_f.c wifi_respond.c main.c stdout_USART.c ESP_con.c e2.c c_struct.c nrf.c nrf_hf.c nrf_de.c co.c vcm.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, CMSIS Driver:SPI:SSP 2.7.0, CMSIS Driver:USART 2.7.0, Compiler:I/O:STDOUT 1.1.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.1.0, Device:Startup 1.0.0
